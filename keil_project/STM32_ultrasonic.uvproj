# Keil uVision project STM32_ultrasonic.uvproj, settings and files
target STM32_ultrasonic (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_ultrasonic +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\inc
  asm include: ..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: STM32F10x.s
    ../src/: GPIO.c main.c NVIC.c ram.c timer.c UART.c ultrasonic.c
  group Driver
    ../src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_flash.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_it.c misc.c
